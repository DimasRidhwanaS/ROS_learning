Commit message: push update 28 Feb

File: src/learn_urdf_pkg/xacro/seven_dof_arm_with_rgbd.xacro (robot description, xacro)
@@ -92,5 +92,5 @@
 	       <box size="1 1 0.02" />
       </geometry>
-      </collision>>
+      </collision>
   </link>
   <gazebo reference="bottom_link">
